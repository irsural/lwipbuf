# IAR project Project.ewp, settings and files
configuration STM32H743I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; IRS_STM32H7xx; USE_STM32H743I_EVAL; USE_IOEXPANDER; USE_LWIP; IRS_USE_UTF8_CPP=1
  ICCARM.CCDiagSuppress: Pa039, Pe261, Pe340, Pa050, Pa091, Pa089, Go005, Pe193, Pa137, Pe826, Pe237, Pe2349, Pe1873, Pe068, Pa109
  ICCARM.CCIncludePath2: ../Inc; ../../../extern_libs/utf8cpp/source/utf8; ../../../extern_libs/utf8cpp/source/; ../Src; ../../../mxsrclib; ../../../mxsrclib/arch/arm_st_hal; ../../Drivers/CMSIS/Include; ../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../Drivers/BSP/Components/; ../../Drivers/BSP/Components/Common; ../../Drivers/BSP/STM32H743I-EVAL; ../../Middlewares/Third_Party/LwIP/src/include/; ../../Middlewares/Third_Party/LwIP/src/apps/; ../../Middlewares/Third_Party/LwIP/system; ../../Utilities; ../../Utilities/LCD; ../../Utilities/Lcd_Trace
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32H743I_EVAL.bin
  ILINK.IlinkOutputFile: STM32H743I_EVAL.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/Inc
    ../Inc/: app_ethernet.h ethernet_h7.h exc7200_conf.h is42s32800g_conf.h lwipopts.h main.h stm32h743i_eval_conf.h stm32h7xx_hal_conf.h stm32h7xx_it.h stmpe811_conf.h ts3510_conf.h utilities_conf.h
  group Application/User/Src
    ../Src/: app_ethernet.c ethernet_h7.c main.cpp stm32h7xx_it.c
  group Application/Utilities
    ../../Utilities/Lcd_Trace/: lcd_trace.c
    ../../Utilities/lcd/: stm32_lcd.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../../Drivers/BSP/Components/lan8742/: lan8742.c
    ../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_sdram.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Middlewares/LwIP
    ../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Api
    ../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core/IPv4
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group mxsrclib
    ../../../mxsrclib/: correct_alg.cpp correct_alg.h csvwork.cpp csvwork.h dbgprn.cpp dbgprn.h hardflowg.cpp hardflowg.h imp_filt.cpp imp_filt.h irs_chart_data.cpp irs_chart_data.h irs_codecvt.h irsadc.cpp irsadc.h irsadcabs.h irsalg.cpp irsalg.h irscalc.cpp irscalc.h irschartwin.h irsconfig.h irsconfig0.h irsconsole.h irsconsolestd.h irscpp.h irscpu.cpp irscpu.h irsdacabs.h irsdbgutil.cpp irsdbgutil.h irsdcp.cpp irsdcp.h irsdefs.h irsdefsbase.h irsdev.cpp irsdev.h irsdevices.cpp irsdevices.h irsdsp.cpp irsdsp.h irsencode.h irserror.cpp irserror.h irsexcept.cpp irsexcept.h irsfilter.cpp irsfilter.h irsfinal.h irsfunnel.cpp irsfunnel.h irsgpio.cpp irsgpio.h irshfftp.cpp irshfftp.h irsinit.cpp irsinit.h irsint.cpp irsint.h irskbd.cpp irskbd.h irslimits.h irslineinterp.h irslocale.cpp irslocale.h irslwip.cpp irslwip.h irslwipbuf.h irsmath.cpp irsmath.h irsmatrix.cpp irsmatrix.h irsmbus.cpp irsmbus.h irsmcutil.cpp irsmcutil.h irsmem.cpp irsmem.h irsmenu.cpp irsmenu.h irsnetdefs.h irsparamabs.h irspch.h irsprop.cpp irsprop.h irsrect.h irsspi.h irsstd.cpp irsstd.h irsstrconv.h irsstrconvbase.h irsstrdefs.h irsstring.cpp irsstring.h irsstrm.cpp irsstrm.h irsstrmstd.h irssysutils.cpp irssysutils.h irstable.h irstcpip.cpp irstcpip.h irstest.h irstime.cpp irstime.h irstree.h irsvariant.cpp irsvariant.h lwipopts_conf.h measdef.h measmul.cpp measmul.h meassup.cpp meassup.h mxdata.cpp mxdata.h mxdatastd.h mxextbase.cpp mxextbase.h mxextchart.cpp mxextchart.h mxifa.h mxifar.cpp mxifar.h mxnet.cpp mxnet.h mxnetc.cpp mxnetc.h mxnetd.h mxnetr.cpp mxnetr.h niusbgpib.cpp niusbgpib.h niusbgpib_hardflow.cpp niusbgpib_hardflow.h timer.cpp timer.h tstlan4abs.h
  group mxsrclib/Arch/Inc
    ../../../mxsrclib/arch/arm_st_hal/: counter.h mxifal.h mxnetda.h
  group mxsrclib/Arch/Src
    ../../../mxsrclib/arch/arm_st_hal/: counter.cpp
